# Keil uVision project Template_FreeRTOS.uvprojx, settings and files
target Template_FreeRTOS (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template_FreeRTOS
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\SYSTEM;.\USER;..\commonlib\USER2;..\commonlib\FWLIB\inc;..\commonlib\FreeRTOS\include;..\commonlib\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../commonlib/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ./SYSTEM/: delay.c key.c led.c sys.c usart.c
  group USER
    ./USER/: main.c stm32f4xx_it.c
    ../commonlib/USER2/: system_stm32f4xx.c
  group README
    ./README/: README.txt
  group FreeRTOS
    ../commonlib/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../commonlib/FreeRTOS/portable/MemMang/: heap_4.c
    ../commonlib/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.1.0
